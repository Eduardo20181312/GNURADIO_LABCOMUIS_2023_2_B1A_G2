options:
  parameters:
    author: Juan_Avila_Jose_Beltran_BIA_G2
    copyright: UIS
    generate_options: qt_gui
    id: Modulador_de_amplitud
    output_language: python
    title: Modulador_AM_GNURadio
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '0.01'
    stop: '500e-3'
    value: '0.25'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.25'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia TX
    start: '0'
    step: '1'
    stop: '31'
    value: '0'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia mensaje
    start: '0'
    step: '100'
    stop: '20000'
    value: '1000'
  states: {}
- name: ka
  id: variable_qtgui_range
  parameters:
    label: coeficiente de sencibilidad
    start: '-4'
    step: '0.01'
    stop: '20'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 195.312e3
  states: {}
- name: CalculoPotencia_1
  id: CalculoPotencia
  parameters:
    l_vect: '1024'
  states: {}
- name: ModuloAm_0
  id: ModuloAm
  parameters:
    Ac: Ac
    ka: ka
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_complex_to_real_2
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Descargas/despecha_rosalia.wav
    repeat: 'True'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    name: '"EnvolventeCompleja"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"envolvente compleja"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48000'
    interp: '200000'
    type: fff
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [ModuloAm_0, '0', blocks_complex_to_real_2, '0']
- [ModuloAm_0, '0', qtgui_freq_sink_x_0, '0']
- [ModuloAm_0, '0', qtgui_time_sink_x_0, '0']
- [ModuloAm_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', ModuloAm_0, '0']
- [blocks_complex_to_real_2, '0', CalculoPotencia_1, '0']
- [blocks_wavfile_source_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', ModuloAm_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
