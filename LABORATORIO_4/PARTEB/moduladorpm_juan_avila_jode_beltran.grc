options:
  parameters:
    author: JUAN_AVILA_JOSE_BELTRAN_B1A_G2
    copyright: SI
    description: Modulacion PM
    generate_options: qt_gui
    id: ModulacionPM
    output_language: python
    title: Modulacion PM
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '0.000001'
    stop: '1'
    value: '1'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: amplitud del mensaje
    start: '0'
    step: '0.000001'
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia de transmicion
    start: '0'
    step: '1'
    stop: '30'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia portadora
    start: '50000000'
    step: '1000000'
    stop: '2000000000'
    value: '200000000'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia del mensaje
    start: '1000'
    step: '100'
    stop: '20000'
    value: '1000'
  states: {}
- name: kp
  id: variable_qtgui_range
  parameters:
    label: coefienciente de sensibilidad fase
    start: '0'
    step: '0.000001'
    stop: '80'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '6250000'
  states: {}
- name: envolventecompleja_pm_b1a_g2_juan_0
  id: envolventecompleja_pm_b1a_g2_juan
  parameters:
    Ac: Ac
    kp: kp
  states: {}
- name: hola
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [envolventecompleja_pm_b1a_g2_juan_0, '0', qtgui_freq_sink_x_0, '0']
- [envolventecompleja_pm_b1a_g2_juan_0, '0', qtgui_time_sink_x_1, '0']
- [envolventecompleja_pm_b1a_g2_juan_0, '0', uhd_usrp_sink_0, '0']
- [hola, '0', envolventecompleja_pm_b1a_g2_juan_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
